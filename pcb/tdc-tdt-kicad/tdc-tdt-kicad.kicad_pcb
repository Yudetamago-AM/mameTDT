# Repository Yudetamago-AM/mameTDT

File Readme.md:

# mameTDT

**This is EXPERIMENTAL sensor for now.**

mameTDTは、TDT（Time Domain Transmissiometry）方式の誘電率センサーです。土の水分量や油の劣化度合いなど、用途に応じていろいろなものを測れます。

以下フォルダの製造ファイルをJLCPCBなどの基板製造・実装業者に入稿すると、実装済み基板が送られてきます。本体とプローブ（先端）は別ファイルなので、気をつけてください。

[本体の製造ファイルはこちら](./pcb/tdc-tdt-kicad/jlcpcb/production_files/)  
[プローブ（30x70mm）の製造ファイルはこちら](./pcb/tdc-tdt-kicad/probe/standard_garber.zip)

## 原理
伝送路上の電磁波の伝播速度$`v[m/s]`$は、$`v=c/\sqrt{\epsilon}`$（光速$`c[m/s]`$、比誘電率$\epsilon$）で与えられます。これを変形すると、$`\epsilon=(c/v)^2`$です。つまり、伝播速度$v$がわかれば比誘電率$`\epsilon`$がわかります。

また、$`速度[m/s]=距離[m]/時間[s]`$という関係から、距離が一定で、時間がわかれば、速度がわかります。

以上から、一定の長さの伝送路の片端に適当に電圧（ステップ波、パルス波など）を加えて、もう片端に達するまでの時間を測れば、伝播速度がわかり、そこから比誘電率もわかります。

ここでは、TDC（Time to Digital Converter）という微少時間測定ICを使って伝播時間を測っています。

## 応用例
- 土壌水分量センサー

土が水・空気・土そのものの混合物だと考えると、誘電率がわかれば、水分量を知ることができます。
多くの場合、誘電率と水分量の関係は、Toppの式と呼ばれる下式で表されます。  

$`\theta=−5.3 × 10^{−2}  + 2.92 × 10^{−2} \epsilon−5.5 × 10^{−4} \epsilon^2+ 4.3 × 10^{−6}\epsilon^3`$  
ただし、土の水分量$`\theta [m^3/m^3]`$、比誘電率$`\epsilon`$です。

## 回路
 
回路図
  
PCBの3Dレンダリング
  
ブロック図

- パルス生成部  
単安定マルチバイブレータICの74LVC1G123で一定幅のパルス波を作り、バッファICで受けます。バッファICの出力をロジックIC（AND回路）の74LVC08APWに入力し、出力を４並列にして、ごく短い立ち上がり時間のパルス波を伝送路に入力します。十分な帯域幅を持ったオシロスコープがないので、確認出来ていませんが、おそらく500psくらいの立ち上がり時間です。

- タイミング管理部・受信部  
TDC7200というTI製のTDC ICを用いています。これは、測定できる最小時間が12nsですが、マイコンから基準開始信号を入力して、その基準からの時間の差を測って、12nsよりも短い時間を測っています。TIのアプリケーションレポートSNAA288を参考にしました。

- 電源回路  
Diodes IncのDCDCコンバータを使っています。USBと外部電源が同時に入力された場合、電圧の高い方を優先します。なお、入力電圧範囲は、4.5V～30Vを推奨します。

- マイコン  
Raspberry Pi財団の作ったマイコンRP2040を使っています。USBでのファームウェア書き込みが容易なことと、PIOというプログラム可能入出力機能が実装上便利だったので、採用しました。

## 使い方

### プログラムの書き込み
1. ここからファームウェアをダウンロードする。  
    （必要があれば、"Getting Started With Raspberry Pi Pico"などを参考に環境構築し、ビルドしてください）
1. 基板上のボタンを押しながら、USBでコンピュータに接続する。
1. USBメモリと同じように、RPI-RP2というドライブが認識されるので、ファームウェアをドラッグアンドドロップする。
1. 完了

### インターフェイス
UARTとUSBに対応しています。ケースに入れる際は、UARTのみの対応です。基板上の印字に従って配線し、適当なシリアル変換器や対応デバイスに接続してご利用ください。

### コマンド
現状、ASCIIコードの't'が入力された際、生の測定値（最大周波数：50Hz程度）を返します。適宜ノイズ処理を行ってご利用ください。

### 校正
少なくとも4点程度での校正をおすすめします。現状、生の値とプローブ長から決まる真値からExcel等で多項式補完して校正曲線を求める方法をおすすめします。校正に使いやすい物質とその比誘電率は次の通りです。

| 物質                     | 比誘電率(温度) | 
| ------------------------ | -------------- | 
| 空気                     | 1              | 
| イソプロパノール         | 19.92(25)      | 
| エタノール70wt%・水30wt% | 39.14(20)      | 
| エタノール40wt%・水60wt% | 56.49(20)      | 
| 水                       | 78.55(25)      | 

## ToDo
- 自動校正機能（プログラム）
- SDI-12への対応（プログラム）

## License
Apache-2.0 License

## KiCad design pcb/tdc-tdt-kicad/tdc-tdt-kicad.kicad_pcb

Parts:
C1, C6, C14, C26: 1u; C_0402_1005Metric
C2, C3, C7, C8, C9, C10, C11, C12, C13, C16, C19, C20, C21, C22, C25, C27: 100n; C_0402_1005Metric
C4, C5: 20p; C_0402_1005Metric
C15: 10p; C_0402_1005Metric
C17, C18, C23, C24: 22u; C_0603_1608Metric
D1, D3: 1N5817WS; D_SOD-323
D2: LED; LED_0603_1608Metric
D4: 1N4148WS; D_SOD-323
F1: Polyfuse; Fuse_0603_1608Metric
IC1: W25Q16JVUXIQ; SON50P300X200X60-9N; Manufacturer_Part_Number W25Q16JVUXIQ
IC2: TDC7200PWR; SOP65P640X120-14N; Manufacturer_Part_Number TDC7200PWR; Mouser Part Number 595-TDC7200PWR
IC4: 74LVC08APW,112; SOP65P640X110-14N; Manufacturer_Part_Number 74LVC08APW,112; Mouser Part Number 771-74LVC08APW
IC5: TS3A44159PWR; SOP65P640X120-16N; Manufacturer_Part_Number TS3A44159PWR; Mouser Part Number 595-TS3A44159PWR
IC6: 74LVC1G125; SOT65P212X110-5N; Manufacturer_Part_Number 74HC1G126GW,125; Mouser Part Number 771-HC1G126GW125
J1: Conn_Transmission_Line; conn_transmission_line
J2: Interface; PinHeader_1x04_P2.54mm_Vertical
L1: 4.7u; L_0603_1608Metric
Q1, Q3: AO3401A; SOT-23
Q4: 2N7002; SOT-23
R1, R2: 27; R_0603_1608Metric
R3, R4: 5.1k; R_0402_1005Metric
R5, R7, R8, R10, R13, R14: 1k; R_0402_1005Metric
R6, R9: 10k; R_0402_1005Metric
R15: 0; R_0402_1005Metric
R16: DNF; R_0402_1005Metric
R19, R20: 50; R_0603_1608Metric
S1: TS-1187A-B-A-B; TS1187ABAB; Manufacturer_Part_Number TS-1187A-B-A-B
U1: USB_type_C
U2: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U3: 74LVC1G123; TSSOP-8_3x3mm_P0.65mm
U4: AP63203WU; TSOT-23-6
Y1: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C1.1, C2.1, C3.1, U2.23 (DVDD), U2.45 (VREG_VOUT), U2.50 (DVDD)
+2V8: C13.2, D4.1 (K), IC2.1 (ENABLE), IC2.14 (VDD)
+3.3V: C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C23.1, C24.1, IC1.8 (VCC), L1.2, Q3.3 (D), R6.2, U2.1 (IOVDD), U2.10 (IOVDD), U2.22 (IOVDD), U2.33 (IOVDD), U2.42 (IOVDD), U2.43 (ADC_AVDD), U2.44 (VREG_IN), U2.48 (USB_VDD), U2.49 (IOVDD), U4.1 (FB)
+3.3VA: C16.1, C19.1, C20.1, C21.1, C25.1, C26.1, D4.2 (A), IC4.14 (VCC), IC5.12 (VCC), IC6.5 (VCC), Q3.2 (S), R7.1, U3.3 (~CLR), U3.8 (VCC)
/AND_IN_ALL: IC4.1 (1A), IC4.2 (1B), IC4.4 (2A), IC4.5 (2B), IC4.9 (3A), IC4.10 (3B), IC4.12 (4A), IC4.13 (4B), IC6.4 (Y)
/AND_OUT: C27.1, IC4.3 (1Y), IC4.6 (2Y), IC4.8 (3Y), IC4.11 (4Y)
/QSPI_SCLK: IC1.6 (CLK), U2.52 (QSPI_SCLK)
/QSPI_SD0: IC1.5 (DI_(IO0)), U2.53 (QSPI_SD0)
/QSPI_SD1: IC1.2 (DO_(IO1)), U2.55 (QSPI_SD1)
/QSPI_SD2: IC1.3 (~WP_(IO2)), U2.54 (QSPI_SD2)
/QSPI_SD3: IC1.7 (~HOLD_OR_RESET_(IO3)), U2.51 (QSPI_SD3)
/QSPI_SS: IC1.1 (~CS), R14.2, U2.56 (QSPI_SS)
/TDC_START: IC2.3 (START), IC5.14 (COM1), R19.1
/TDC_STOP: IC2.4 (STOP), IC5.6 (COM_3), R20.1
/USB_BD_N: R2.2, U2.46 (USB_DM)
/USB_BD_P: R1.2, U2.47 (USB_DP)
/USB_D_N: R2.1, U1.5 (B7_DN2), U1.7 (A7_DN1)
/USB_D_P: R1.1, U1.6 (A6_DP1), U1.8 (B6_DP2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C23.2, C24.2, C25.2, C26.2, D2.1 (K), D3.2 (A), IC1.4 (GND), IC1.9 (EP), IC2.7 (GND), IC4.7 (GND), IC5.4 (GND), IC6.1 (OE), IC6.3 (GND), J1.2, J2.4, Q4.2 (S), R3.2, R4.2, R9.1, R19.2, R20.2, S1.C1 (NO_1), S1.D1 (NO_2), U1.1 (A1-B12_GND), U1.12 (A12-B1_GND), U1.S (SHIELD), U2.19 (TESTEN), U2.57 (GND), U3.1 (~A), U3.4 (GND), U4.4 (GND), Y1.2, Y1.4
INT_TDC_DONE: IC2.8 (INTB), U2.16 (GPIO13)
MUX1: IC5.16 (IN_1-2), U2.29 (GPIO18)
MUX2: IC5.8 (IN_3-4), U2.11 (GPIO8)
unnamed: D1.1 (K), F1.1, Q1.2 (S)
unnamed: D2.2 (A), R8.2
unnamed: IC2.2 (TRIGG), R16.1
unnamed: C14.2, IC2.13 (VREG)
unnamed: IC6.2 (A), U3.5 (Q)
unnamed: Q3.1 (G), R6.1, R10.2
unnamed: Q4.3 (D), R10.1
unnamed: Q4.1 (G), R5.2, R9.2
unnamed: R14.1, S1.A1 (COM_1), S1.B1 (COM_2)
unnamed: R3.1, U1.4 (A5_CC1)
unnamed: R4.1, U1.10 (B5_CC2)
unnamed: R15.1, U2.32 (GPIO21)
unnamed: R8.1, U2.37 (GPIO25)
unnamed: R13.2, U2.20 (XIN)
unnamed: C15.2, U3.6 (Cext)
unnamed: C15.1, R7.2, U3.7 (RCext)
unnamed: C22.1, U4.6 (BST)
unnamed: C17.1, C18.1, F1.2, U4.3 (IN)
unnamed: C22.2, L1.1, U4.5 (SW)
PM_VCC: R5.1, U2.8 (GPIO6)
REF_START: IC5.15 (NC_1), U2.30 (GPIO19)
RUN: U2.26 (RUN)
SPI1_CS: IC2.11 (CSB), U2.12 (GPIO9)
SPI1_MISO: IC2.9 (DOUT), U2.15 (GPIO12)
SPI1_MOSI: IC2.10 (DIN), U2.14 (GPIO11)
SPI1_SCK: IC2.12 (SCLK), U2.13 (GPIO10)
SWCLK: U2.24 (SWCLK)
SWD: U2.25 (SWD)
TRAN_START: C27.2, IC5.7 (NC_3), IC5.13 (NO1), J1.1
TRAN_STOP: D3.1 (K), IC5.5 (NO_3), J1.3
TRIG_PULSE: R15.2, R16.2, U3.2 (B)
UART1_RX: J2.2, U2.7 (GPIO5)
UART1_TX: J2.3, U2.6 (GPIO4)
VBUS: D1.2 (A), Q1.1 (G), U1.2 (A4-B9_VBUS), U1.11 (A9-B4_VBUS)
VCC: J2.1, Q1.3 (D)
XIN: C4.1, IC2.5 (CLOCK), R13.1, Y1.1
XOUT: C5.1, U2.21 (XOUT), Y1.3

Notes on the sheet:
LOW: NC1/2 HIGH: NO1/2
200: W=VA=3.3*24m=79.2m>62mW(1005)
Pulse
Power
delay 12ns~ => HC series
ERC! DRC! フットプリントダブルチェック！
MCU
/CLR /A B Q H L ↑ 凸 Rext=1k,Cext=10p => tw=70ns
Eratta: OE should be connected to GND
Measure

Board: 4 copper layers, 41.0 x 34.0 mm, 65 parts (0 on the bottom side), 56 nets.

File pcb/tdc-tdt-kicad/jlcpcb/production_files/BOM-tdc-tdt-kicad.csv:

Comment,Designator,Footprint,LCSC
4.7u,L1,L_0603_1608Metric,C1034
1k,"R10,R13,R14,R5,R7,R8",R_0402_1005Metric,C11702
74LVC1G125,IC6,SOT65P212X110-5N,C12519
AO3401A,"Q1,Q3",SOT-23,C15127
TS3A44159PWR,IC5,SOP65P640X120-16N,C151886
100n,"C10,C11,C12,C13,C16,C19,C2,C20,C21,C22,C25,C27,C3,C7,C8,C9",C_0402_1005Metric,C1525
20p,"C4,C5",C_0402_1005Metric,C1554
0,R15,R_0402_1005Metric,C17168
1N5817WS,"D1,D3",D_SOD-323,C191023
RP2040,U2,QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm,C2040
Polyfuse,F1,Fuse_0603_1608Metric,C21189
1N4148WS,D4,D_SOD-323,C2128
50,"R19,R20",R_0603_1608Metric,C22843
LED,D2,LED_0603_1608Metric,C2286
10k,"R6,R9",R_0402_1005Metric,C25744
5.1k,"R3,R4",R_0402_1005Metric,C25905
TDC7200PWR,IC2,SOP65P640X120-14N,C2653139
W25Q16JVUXIQ,IC1,SON50P300X200X60-9N,C2843335
USB_type_C,U1,USB_type_C,C2874568
TS-1187A-B-A-B,S1,TS1187ABAB,C318884
10p,C15,C_0402_1005Metric,C32949
27,"R1,R2",R_0603_1608Metric,C4275
74LVC1G123,U3,TSSOP-8_3x3mm_P0.65mm,C513291
1u,"C1,C14,C26,C6",C_0402_1005Metric,C52923
22u,"C17,C18,C23,C24",C_0603_1608Metric,C59461
"74LVC08APW,112",IC4,SOP65P640X110-14N,C6053
AP63203WU,U4,TSOT-23-6,C780769
2N7002,Q4,SOT-23,C8545
Crystal_GND24,Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm,C9002
Interface,J2,PinHeader_1x04_P2.54mm_Vertical,
Conn_Transmission_Line,J1,conn_transmission_line,
DNF,R16,R_0402_1005Metric,

## Code that names these connections

File code/main3/main3.c:

#include <stdint.h>
#include <stdio.h>
#include "hardware/timer.h"
#include "pico/stdlib.h"
#include "hardware/pio.h"
#include "hardware/spi.h"
#include "pio_out.pio.h"

#define abs(x) (((x)<0)?(-(x)):(x))

const uint8_t pin_mux1 = 18; // LOW: REF_START, HIGH: TRAN_START
const uint8_t pin_mux2 = 8; // LOW: TRAN_START, HIGH: TRAN_STOP
const uint8_t pin_ref_start = 19;
const uint8_t pin_trig_pulse = 21; // Rising edge: Trigger pulse
const uint8_t pin_mes_vcc = 6; // LOW: ON, HIGH: OFF
const uint8_t pin_int_tdc = 13; // HIGH: data ready, LOW: else

const uint8_t pin_spi1_cs = 9; // Active LOW
const uint8_t pin_spi1_sck = 10;
const uint8_t pin_spi1_mosi = 11;
const uint8_t pin_spi1_miso = 12;

enum tdc_mode {
	RISE_RISE = 0b10000001,
	RISE_FALL = 0b10010001,
	FALL_RISE = 0b10001001,
	FALL_FALL = 0b10011001,
};

uint32_t readData(uint8_t addr) {
	uint8_t buf[3] = {0};
	gpio_put(pin_spi1_cs, 0);
	asm volatile("nop \n nop \n nop");
	spi_write_blocking(spi1, &addr, 1);
	spi_read_blocking(spi1, 0x00, buf, 3);
	asm volatile("nop");
	gpio_put(pin_spi1_cs, 1);
	return ((buf[0] << 16) | (buf[1] << 8) | buf[2]);
}

double measure(PIO pio, uint8_t sm, enum tdc_mode mode) {
	uint8_t wbuf[2] = {0};
	//    uint32_t time_before = time_us_32(), time_after;
	//    printf("trigg. %d ms, ", time_before / 1000);

	// start generating pulse by PIO
	pio_sm_set_enabled(pio, sm, true);

	// start measuring in TDC
	gpio_put(pin_spi1_cs, 0);
	asm volatile("nop \n nop \n nop");
	wbuf[0] = 0b01000000; // Write Reg 0x00
						  //  wbuf[1] = 0b10000001; // Mode 1, START: Rising, STOP: Rising Edge
						  //	wbuf[1] = 0b10010001; // Mode 1, START: Rising, STOP: Falling Edge
						  //  wbuf[1] = 0b10011001; // Mode 1, START: Falling, STOP: Falling Edge
						  //  wbuf[1] = 0b10001001; // Mode 1, START: Falling, STOP: Rising Edge
						  //	wbuf[2] = 0b01111000; // 128 times averaging(should be auto incrementing enabled)
	wbuf[1] = mode;
	spi_write_blocking(spi1, wbuf, 2);
	asm volatile("nop");
	gpio_put(pin_spi1_cs, 1);

	//while (gpio_get(pin_int_tdc) == 0){tight_loop_contents();}
	sleep_us(2);
	//    printf("gpio_get(pin_int_tdc): %d\n", gpio_get(pin_int_tdc));

	// end generating pulse by PIO
	pio_sm_set_enabled(pio, sm, false);

	// read out data
	uint32_t time1 = readData(0x10);
	//    uint32_t clock_cnt1 = readData(0x11);
	uint32_t calib1 = readData(0x1b);
	uint32_t calib2 = readData(0x1c);
	double cal_count = (calib2 - calib1) / (10.0 - 1.0);
	double norm_LSB = 1 / (cal_count * 12.0 / 1000);
	//double tof1 = time1 * norm_LSB + clock_cnt1 * (1 / (12.0));
	double tof1 = time1 * norm_LSB;
	//   printf("tof: %f ns, elapsed: %d us\n", tof1, (time_us_32()-time_before));
	//printf("time1: %d, clock_cnt1: %d, calib1: %d, calib2: %d, cal_count: %f, norm_LSB: %f\n", time1, clock_cnt1, calib2, cal_count, norm_LSB);
	//   printf("time1: %d, calib1: %d, calib2: %d, cal_count: %f, norm_LSB: %f\n", time1, calib1, calib2, cal_count, norm_LSB);
	// 	time_after = time_us_32();
	//	printf("elapsed: %d us, ", time_after - time_before);

	return tof1;
}

double measure_avg256(PIO pio, uint8_t sm, uint8_t mux2, uint8_t mode) {
	double sum = 0.0, start = 0.0, stop = 0.0, diff = 0.0;
	printf("trigg. %d ms, mux2: 0x%x, mode: 0x%x ", time_us_32() / 1000, mux2, mode);
	printf("START: ");
	gpio_put(pin_mux2, (mux2>>1));
	asm volatile("nop");

	sum = 0;
	//			before = time_us_32();
	for (int8_t i = 0; i < 64; i++) sum += measure(pio, sm, mode);
	for (int8_t i = 0; i < 64; i++) sum += measure(pio, sm, mode);
	for (int8_t i = 0; i < 64; i++) sum += measure(pio, sm, mode);
	for (int8_t i = 0; i < 64; i++) sum += measure(pio, sm, mode);
	//			after = time_us_32();
	//			printf("T: %d us, ", (after - before) / 64);
	start = sum / 256.0;

	printf("tof: %2.3f, ", start);
	printf("STOP: ");
	gpio_put(pin_mux2, (mux2&0x01));
	asm volatile("nop");

	sum = 0;
	for (int8_t i = 0; i < 64; i++) sum += measure(pio, sm, mode);
	for (int8_t i = 0; i < 64; i++) sum += measure(pio, sm, mode);
	for (int8_t i = 0; i < 64; i++) sum += measure(pio, sm, mode);
	for (int8_t i = 0; i < 64; i++) sum += measure(pio, sm, mode);
	stop = sum / 256.0;
	diff = stop - start;
	printf("tof: %2.3f, ", stop);
	printf("diff: %2.3f", diff);
	printf("\n");

	return diff;
}

int main(void) {
	stdio_init_all();
	sleep_ms(2000);
	printf("hello, this is main\n");

	//    gpio_init(pin_trig_pulse);
	//    gpio_set_dir(pin_trig_pulse, GPIO_OUT);
	//    gpio_put(pin_trig_pulse, 0); // no pulse

	gpio_init(pin_mes_vcc);
	gpio_set_dir(pin_mes_vcc, GPIO_OUT);
	gpio_put(pin_mes_vcc, 0); // on

	gpio_init(pin_mux1);
	gpio_set_dir(pin_mux1, GPIO_OUT);
	gpio_put(pin_mux1, 0); // REF_START

	gpio_init(pin_mux2);
	gpio_set_dir(pin_mux2, GPIO_OUT);
	gpio_put(pin_mux2, 0);

	//    gpio_init(pin_ref_start);
	//    gpio_set_dir(pin_ref_start, GPIO_OUT);
	//    gpio_put(pin_ref_start, 0);

	gpio_init(pin_int_tdc);
	gpio_set_dir(pin_int_tdc, GPIO_IN);

	gpio_init(pin_spi1_cs);
	gpio_set_dir(pin_spi1_cs, GPIO_OUT);
	gpio_put(pin_spi1_cs, 1); // Active LOW

	spi_init(spi1, 10 * 1000 * 1000); // 10MHz
	gpio_set_function(pin_spi1_miso, GPIO_FUNC_SPI);
	gpio_set_function(pin_spi1_sck, GPIO_FUNC_SPI);
	gpio_set_function(pin_spi1_mosi, GPIO_FUNC_SPI);

	uint8_t wbuf[2] = {0};
	gpio_put(pin_spi1_cs, 0);
	asm volatile("nop \n nop \n nop");
	wbuf[0] = 0b01000011; // Write Reg 0x03
	wbuf[1] = 0b00000111; // enable interrupt
	spi_write_blocking(spi1, wbuf, 3);
	asm volatile("nop");
	gpio_put(pin_spi1_cs, 1);
	//    gpio_put(pin_spi1_cs, 0);
	//    asm volatile("nop \n nop \n nop");
	//    wbuf[0] = 0b01000001; // Write Reg 0x01
	//    wbuf[1] = 0b01111000; // enable 128 times averaging
	//    spi_write_blocking(spi1, wbuf, 3);
	//    asm volatile("nop");
	//    gpio_put(pin_spi1_cs, 1);

	// PIO settings
	PIO pio = pio0;
	uint8_t offset = pio_add_program(pio, &pio_out_program);
	uint8_t sm = pio_claim_unused_sm(pio, true);
	pio_out_program_init(pio, sm, offset, pin_ref_start);

	char c = 0;
	while (1) {
		if ((c = getchar_timeout_us(10*1000)) == 't') {
			// A: stArt, O: stOp, R: Rise, F: Fall
			double mes_AA_RR = 0.0, mes_AA_FF = 0.0,
				   mes_OO_RR = 0.0, mes_OO_FF = 0.0;
			const double V_RR = 2.8;
			double V_FF = 0.5;

			// START to START: mux2==0b00
			// RISE to RISE
			mes_AA_RR = measure_avg256(pio, sm, 0b00, RISE_RISE);
			// FALL to FALL
			mes_AA_FF = measure_avg256(pio, sm, 0b00, FALL_FALL);

			// START to STOP: mux2==0b01
			// RISE to RISE
			mes_OO_RR = measure_avg256(pio, sm, 0b01, RISE_RISE);
			// FALL to FALL
			mes_OO_FF = measure_avg256(pio, sm, 0b01, FALL_FALL);

			double t_RR = mes_OO_RR - abs(mes_AA_RR);
			double t_FF = mes_OO_FF - abs(mes_AA_FF);

			// guess true propagation delay
			double x = (V_FF*t_RR - V_RR*t_FF) / (t_FF - t_RR);
			x = abs(x);
			double t_p = (t_FF * x) / (V_FF + x);
			printf("V_RR: %1.1f V_FF: %1.1f ", V_RR, V_FF);
			printf("x: %2.3f t_p: %2.3f\n", x, t_p);

		}
		//sleep_ms(1);
	}
}

## Commit log

2024-02-22 update docs
2024-02-22 fix docs
2024-02-22 fix eqs
